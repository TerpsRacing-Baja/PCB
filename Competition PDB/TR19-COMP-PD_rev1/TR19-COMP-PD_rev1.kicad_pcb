# Repository TerpsRacing-Baja/PCB

File README.md:

**Archived 10-26-2021**

## Welcome to GitHub Pages

You can use the [editor on GitHub](https://github.com/TerpsRacing-Baja/PCB/edit/master/README.md) to maintain and preview the content for your website in Markdown files.

Whenever you commit to this repository, GitHub Pages will run [Jekyll](https://jekyllrb.com/) to rebuild the pages in your site, from the content in your Markdown files.

### Markdown

Markdown is a lightweight and easy-to-use syntax for styling your writing. It includes conventions for

```markdown
Syntax highlighted code block

# Header 1
## Header 2
### Header 3

- Bulleted
- List

1. Numbered
2. List

**Bold** and _Italic_ and `Code` text

[Link](url) and 
```

For more details see [GitHub Flavored Markdown](https://guides.github.com/features/mastering-markdown/).

### Jekyll Themes

Your Pages site will use the layout and styles from the Jekyll theme you have selected in your [repository settings](https://github.com/TerpsRacing-Baja/PCB/settings). The name of this theme is saved in the Jekyll `_config.yml` configuration file.

### Support or Contact

Having trouble with Pages? Check out our [documentation](https://help.github.com/categories/github-pages-basics/) or [contact support](https://github.com/contact) and we’ll help you sort it out.

## KiCad design Competition PDB/TR19-COMP-PD_rev1/TR19-COMP-PD_rev1.kicad_pcb

Parts:
AD1: ArduinoDue; ARDUINO_DUE_SHIELD_V2
D1: 5V_Zener; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
DC1: SUCW61212B-ND; 1776-2753-ND
DC2: CC6-1205SR-E; 445-2487-ND; Voltage 5V
J1: PWR BTN; PinHeader_1x02_P2.54mm_Vertical
J2: PWR_LED; PinHeader_1x02_P2.54mm_Vertical
J3: PTT_LED; PinHeader_1x02_P2.54mm_Vertical
J4: Servo1; PinHeader_1x03_P2.54mm_Vertical
J5: Servo2; PinHeader_1x03_P2.54mm_Vertical
J6: Servo3; PinHeader_1x03_P2.54mm_Vertical
J7: BATT CONN; PinHeader_1x02_P2.54mm_Vertical
J8: RGB_LED1; PinHeader_1x04_P2.54mm_Vertical
J9: RGB_LED2; PinHeader_1x04_P2.54mm_Vertical
J10: RGB_LED3; PinHeader_1x04_P2.54mm_Vertical
J11: Sen1; PinHeader_1x03_P2.54mm_Vertical
J12: Sen2; PinHeader_1x03_P2.54mm_Vertical
J13: Sen3; PinHeader_1x03_P2.54mm_Vertical
J14: Sen4; PinHeader_1x03_P2.54mm_Vertical
J15: BTN1; PinHeader_1x02_P2.54mm_Vertical
J16: BTN2; PinHeader_1x02_P2.54mm_Vertical
J17: BTN3; PinHeader_1x02_P2.54mm_Vertical
J18: BTN4; PinHeader_1x02_P2.54mm_Vertical
J19: BTN5; PinHeader_1x02_P2.54mm_Vertical
J20: BTN6; PinHeader_1x02_P2.54mm_Vertical
J21: BTN7; PinHeader_1x02_P2.54mm_Vertical
J22: BTN8; PinHeader_1x02_P2.54mm_Vertical
J23: BTN9; PinHeader_1x02_P2.54mm_Vertical
J24: Sen5; PinHeader_1x03_P2.54mm_Vertical
J25: Sen6; PinHeader_1x03_P2.54mm_Vertical
J26: Sen7; PinHeader_1x03_P2.54mm_Vertical
J27: Sen8; PinHeader_1x03_P2.54mm_Vertical
J28: BTN10; PinHeader_1x02_P2.54mm_Vertical
J29: BTN11; PinHeader_1x02_P2.54mm_Vertical
J30: BTN12; PinHeader_1x02_P2.54mm_Vertical
J31: BTN13; PinHeader_1x02_P2.54mm_Vertical
J32: BTN14; PinHeader_1x02_P2.54mm_Vertical
J33: BTN15; PinHeader_1x02_P2.54mm_Vertical
J34: BTN16; PinHeader_1x02_P2.54mm_Vertical
J35: LED1; PinHeader_1x02_P2.54mm_Vertical
J36: LED2; PinHeader_1x02_P2.54mm_Vertical
J37: LED3; PinHeader_1x02_P2.54mm_Vertical
J38: LED4; PinHeader_1x02_P2.54mm_Vertical
J39: LED5; PinHeader_1x02_P2.54mm_Vertical
J40: LED6; PinHeader_1x02_P2.54mm_Vertical
J41: LED7; PinHeader_1x02_P2.54mm_Vertical
J42: LED8; PinHeader_1x02_P2.54mm_Vertical
J43: LED9; PinHeader_1x02_P2.54mm_Vertical
J44: LED10; PinHeader_1x02_P2.54mm_Vertical
J45: LED11; PinHeader_1x02_P2.54mm_Vertical
J46: LED12; PinHeader_1x02_P2.54mm_Vertical
J47: LED13; PinHeader_1x02_P2.54mm_Vertical
J48: LED14; PinHeader_1x02_P2.54mm_Vertical
J49: LED15; PinHeader_1x02_P2.54mm_Vertical
J50: LED16; PinHeader_1x02_P2.54mm_Vertical
R1: R1; R_1210_3225Metric_Pad1.42x2.65mm_HandSolder
R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76: R_US; R_1210_3225Metric_Pad1.42x2.65mm_HandSolder
U1, U2, U3, U4: SN74AHCT125_N_14; SN74AHCT125N

Connections:
3.3V: AD1.3V3, J15.1, J16.1, J17.1, J18.1, J19.1, J20.1, J21.1, J22.1, J23.1, J28.1, J29.1, J30.1, J31.1, J32.1, J33.1, J34.1
5V: DC2.7, J2.2, J3.2, J4.1, J5.1, J6.1, J11.1, J12.1, J13.1, J14.1, J24.1, J25.1, J26.1, J27.1, R61.1, R62.1, R63.1, R64.1, R65.1, R66.1, R67.1, R68.1, R69.1, R70.1, R71.1, R72.1, R73.1, R74.1, R75.1, R76.1, U1.2, U1.5, U1.9, U1.12, U1.14, U2.2, U2.5, U2.9, U2.12, U2.14, U3.2, U3.5, U3.9, U3.12, U3.14, U4.2, U4.5, U4.9, U4.12, U4.14
12V: AD1.V_IN, DC1.4, DC2.1
A0: AD1.AD0, R16.1, R23.2
A1: AD1.AD1, R17.1, R24.2
A2: AD1.AD2, R18.1, R25.2
A3: AD1.AD3, R19.1, R26.2
A4: AD1.AD4, R34.1, R41.2
A5: AD1.AD5, R35.1, R42.2
A6: AD1.AD6, R36.1, R43.2
A7: AD1.AD7, R37.1, R44.2
ANG0: J11.2, R16.2
ANG1: J12.2, R17.2
ANG2: J13.2, R18.2
ANG3: J14.2, R19.2
ANG4: J24.2, R34.2
ANG5: J25.2, R35.2
ANG6: J26.2, R36.2
ANG7: J27.2, R37.2
B1: J8.3, R6.1
B2: J9.3, R22.1
B3: J10.3, R40.1
Batt(+): DC1.3, J7.2, R1.2
Batt(-): D1.2 (A), DC1.1, J7.1
DIG1: AD1.22, J15.2, R7.2
DIG2: AD1.23, R73.2, U1.1
DIG3: AD1.24, J16.2, R8.2
DIG4: AD1.25, R74.2, U1.4
DIG5: AD1.26, J17.2, R9.2
DIG6: AD1.27, R75.2, U1.13
DIG7: AD1.28, J18.2, R10.2
DIG8: AD1.29, R76.2, U1.10
DIG9: AD1.30, J19.2, R11.2
DIG10: AD1.31, R69.2, U2.1
DIG11: AD1.32, J20.2, R12.2
DIG12: AD1.33, R70.2, U2.4
DIG13: AD1.34, J21.2, R13.2
DIG14: AD1.35, R71.2, U2.13
DIG15: AD1.36, J22.2, R14.2
DIG16: AD1.37, R72.2, U2.10
DIG17: AD1.38, J23.2, R15.2
DIG18: AD1.39, R65.2, U3.1
DIG19: AD1.40, J28.2, R27.2
DIG20: AD1.41, R66.2, U3.4
DIG21: AD1.42, J29.2, R28.2
DIG22: AD1.43, R67.2, U3.13
DIG23: AD1.44, J30.2, R29.2
DIG24: AD1.45, R68.2, U3.10
DIG25: AD1.46, J31.2, R30.2
DIG26: AD1.47, R61.2, U4.1
DIG27: AD1.48, J32.2, R31.2
DIG28: AD1.49, R62.2, U4.4
DIG29: AD1.50, J33.2, R32.2
DIG30: AD1.51, R63.2, U4.13
DIG31: AD1.52, J34.2, R33.2
DIG32: AD1.53, R64.2, U4.10
G1: J8.2, R5.1
G2: J9.2, R21.1
G3: J10.2, R39.1
GND: AD1.GND1, DC2.5, J4.3, J5.3, J6.3, J8.4, J9.4, J10.4, J11.3, J12.3, J13.3, J14.3, J24.3, J25.3, J26.3, J27.3, R2.2, R3.2, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R41.1, R42.1, R43.1, R44.1, R45.2, R46.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, U1.7, U2.7, U3.7, U4.7
LED1(+): J35.2, U1.3
LED2(+): J36.2, U1.6
LED3(+): J37.2, U1.11
LED4(+): J38.2, U1.8
LED5(+): J39.2, U2.3
LED6(+): J40.2, U2.6
LED7(+): J41.2, U2.11
LED8(+): J42.2, U2.8
LED9(+): J43.2, U3.3
LED10(+): J44.2, U3.6
LED11(+): J45.2, U3.11
LED12(+): J46.2, U3.8
LED13(+): J47.2, U4.3
LED14(+): J48.2, U4.6
LED15(+): J49.2, U4.11
LED16(+): J50.2, U4.8
unnamed: DC1.5, DC2.3
unnamed: J2.1, R2.1
unnamed: J3.1, R3.1
unnamed: J35.1, R45.1
unnamed: J36.1, R46.1
unnamed: J37.1, R47.1
unnamed: J38.1, R48.1
unnamed: J39.1, R49.1
unnamed: J40.1, R50.1
unnamed: J41.1, R51.1
unnamed: J42.1, R52.1
unnamed: J43.1, R53.1
unnamed: J44.1, R54.1
unnamed: J45.1, R55.1
unnamed: J46.1, R56.1
unnamed: J47.1, R57.1
unnamed: J48.1, R58.1
unnamed: J49.1, R59.1
unnamed: J50.1, R60.1
PWM1: AD1.2, R4.2
PWM2: AD1.3, R5.2
PWM3: AD1.4, R6.2
PWM4: AD1.5, R20.2
PWM5: AD1.6, R21.2
PWM6: AD1.7, R22.2
PWM7: AD1.8, R38.2
PWM8: AD1.9, R39.2
PWM9: AD1.10, R40.2
PWM10: AD1.11, J4.2
PWM11: AD1.12, J5.2
PWM12: AD1.13, J6.2
PWR_BTN1: J1.2, R1.1
PWR_BTN2: D1.1 (K), DC1.2, J1.1
R1: J8.1, R4.1
R2: J9.1, R20.1
R3: J10.1, R38.1

Board: 2 copper layers, 134 parts (0 on the bottom side), 112 nets.

## KiCad design Rear_PD/TR19-PDR_rev1/TR19-PDR_rev1.kicad_pcb

Board: 2 copper layers, 5 parts (0 on the bottom side), 13 nets.

Parts:
D1: LED; LED_D3.0mm
DC1: CC6-1205SR-E; 445-2487-ND
J1: Conn_01x11_Female; PinHeader_1x11_P2.54mm_Horizontal
J2: Conn_01x12_Female; PinHeader_1x12_P2.54mm_Horizontal
R1: R_US; R_1806_4516Metric_Pad1.57x1.80mm_HandSolder

Connections:
GND: D1.1, DC1.3, DC1.5, J1.2, J2.3
unnamed: D1.2, R1.1
unnamed: DC1.1, J1.3, J2.2
unnamed: DC1.7, J2.4, R1.2
unnamed: J1.1, J2.1
unnamed: J1.4, J2.5
unnamed: J1.5, J2.6
unnamed: J1.6, J2.7
unnamed: J1.7, J2.8
unnamed: J1.8, J2.9
unnamed: J1.9, J2.10
unnamed: J1.10, J2.11
unnamed: J1.11, J2.12

## Commit log

2018-10-21 Set theme jekyll-theme-tactile
2018-10-21 Restructuring
2018-10-21 Readme init
2019-02-03 PD_F
    Initial Push PDf
2019-02-03 PCB Lib
    5V regulator
2019-02-03 Adding in part symbol for 12 V DC-DC converter
2019-02-03 PDF Schematic
2019-02-05 PDB and PDR KiCad Schematics
2019-02-10 12V DC-DC Converter Footprint
2019-02-17 PDB FRONT and REAR PCB Layouts
2019-02-20 PDB PCB Updates
2019-02-24 PDB PCB Traces
2019-03-01 Competition PDB Sketch
2019-03-14 Comp PDB Boards
2019-04-03 Arduino DUE Shield schematic and footprint
2019-04-19 Baja Competition PCBs
2019-04-19 New Pads
    New Pads
2019-04-24 Add pull up resistors for LED drivers
2019-04-24 V2
    Version 2 Final update
2019-04-24 V2 Update
    Gerbers
2019-04-24 Final Comp PDB Updates

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
